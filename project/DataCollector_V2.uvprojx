# Keil uVision project DataCollector_V2.uvprojx, settings and files
target DataCollector_V2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DataCollector_V2
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..;..\types;..\app;..\drivers;..\modules;..\utils;..\startup;..\..\User;..\..\CMSIS;..\..\CMSIS\GD\GD32F4xx\Include;..\..\Library\GD32F4xx_standard_peripheral\Include;..\..\Fatfs;..\..\HardWare\SDCARD;..\..\HardWare\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../: main.c
    ../app/: app_main.c
  group Drivers
    ../drivers/: adc_driver.c key_driver.c led_driver.c oled_driver.c rtc_driver.c sd_card_driver.c spi_flash_driver.c timer_driver.c uart_driver.c
  group Modules
    ../modules/: command.c config_manager.c data_logger.c self_test.c
  group Utils
    ../utils/: ring_buffer.c event_queue.c filter.c data_encoder.c unicode_stub.c
  group Startup
    ../../CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
    ../startup/: gd32f4xx_it.c
  group System
    ../../CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Library
    ../../Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group FatFs
    ../../Fatfs/: diskio.c ff.c
  group SDCard
    ../../HardWare/SDCARD/: sdcard.c
  group Doc
    ../: README.md
software components: CMSIS:CORE 6.2.0
